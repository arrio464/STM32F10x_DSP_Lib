# IAR project Project.ewp, settings and files
configuration STM3210B-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\DSPLib\include; ..\..\..\FWLib\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: STM3210B-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../: readme.txt
  group DSPLib
    ../../../DSPLib/source/asm/EWARMv5/: cr4_fft_1024_stm32.s cr4_fft_256_stm32.s cr4_fft_64_stm32.s fir_stm32.s iirarma_stm32.s PID_stm32.s
    ../../../DSPLib/source/: iir_stm32.c PID_C_stm32.c
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../../FWLib/library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c
  group User
    ../../source/: main.c stm32f10x_it.c stm32f10x_lcd.c
